<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sss_corr3_gui</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>from sss_corr import *   </value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from pss_corr import *  </value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_corr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_id_1</value></param>
<param><key>value</key><value>134</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>avg_frames</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_id_2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>16</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rot</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>noise_level</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>10</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>gr_fft_vxx</key>
<param><key>id</key><value>gr_fft_vxx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value>window.blackmanharris(1024)</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>nthreads</key><value>1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>input_gen_td</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>sss_vec_fd</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>pss_vec_fd</value></param>
</block>
<block>
<key>pss_chan_est</key>
<param><key>id</key><value>pss_chan_est_0</value></param>
<param><key>decim</key><value>16</value></param>
<param><key>N_id_2</key><value>0</value></param>
<param><key>is_input_td</key><value>0</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_0_1_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_0_1_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>0.005*exp(rot*2*numpy.pi*1j)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_integrate_xx</key>
<param><key>id</key><value>gr_integrate_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>decim</key><value>fft_size</value></param>
</block>
<block>
<key>gr_repeat</key>
<param><key>id</key><value>gr_repeat_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interp</key><value>fft_size</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_conjugate_cc</key>
<param><key>id</key><value>gr_conjugate_cc_1</value></param>
</block>
<block>
<key>gr_interleave</key>
<param><key>id</key><value>gr_interleave_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_4</value></param>
<param><key>stream_id</key><value>sss_phase_error_comp</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>gr_stream_to_vector</key>
<param><key>id</key><value>gr_stream_to_vector_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_complex_to_mag_squared</key>
<param><key>id</key><value>gr_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>stream_id</key><value>sss_vec_fd</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>sss_est_fd</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_0_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fft_size</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>sss_vec_fd</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>pss_vec_fd</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>input_gen_td</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/user/git/gr-lte/gr-lte/test/foo_pss0_sss_in.cfile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_deinterleave</key>
<param><key>id</key><value>gr_deinterleave_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>gr_stream_to_vector</key>
<param><key>id</key><value>gr_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_noise_source_x</key>
<param><key>id</key><value>gr_noise_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>gr.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>noise_level</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>gr_add_xx</key>
<param><key>id</key><value>gr_add_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_fft_vxx</key>
<param><key>id</key><value>gr_fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(1024)</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>nthreads</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vec_half_frame</value></param>
<param><key>value</key><value>30720*5/decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>2048/decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>30720e3/decim</value></param>
</block>
<block>
<key>gr_interleave</key>
<param><key>id</key><value>gr_interleave_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>4</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>gen_pss_fd(N_id_2, fft_size, False).get_data()</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>gen_sss_fd( N_id_1, N_id_2, fft_size).get_sss(True)</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>gen_pss_fd(N_id_2, fft_size, False).get_data()</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>gen_sss_fd( N_id_1, N_id_2, fft_size).get_sss(False)</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>numpy.conjugate(gen_sss_fd(N_id_1,N_id_2, fft_size).get_sss(True))</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>numpy.conjugate(gen_sss_fd(N_id_1,N_id_2, fft_size).get_sss(False))</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_4_0</value></param>
<param><key>stream_id</key><value>sss_ref_fd</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>sss_est_fd</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>stream_id</key><value>sss_vec_fd</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3_0</value></param>
<param><key>stream_id</key><value>sss_phase_error_comp</value></param>
</block>
<block>
<key>gr_sub_xx</key>
<param><key>id</key><value>gr_sub_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_size</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>gr_channel_model</key>
<param><key>id</key><value>gr_channel_model_0</value></param>
<param><key>noise_voltage</key><value>0.005*noise_level</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>epsilon</key><value>1</value></param>
<param><key>taps</key><value>0.005*exp(rot*2*numpy.pi*1j)</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>sss_est_fd</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>sss_ref_fd</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_complex_to_float</key>
<param><key>id</key><value>gr_complex_to_float_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_0_2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>-1e-3</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>notebook_0</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['tab1', 'tab2', 'tab3']</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>notebook</key><value>notebook_0,0</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>notebook</key><value>notebook_0,1</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_0_2_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_0_2_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3_1</value></param>
<param><key>stream_id</key><value>sss_ref_fd</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1</value></param>
<param><key>stream_id</key><value>sss_est_fd</value></param>
</block>
<block>
<key>gr_keep_m_in_n</key>
<param><key>id</key><value>gr_keep_m_in_n_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>2</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_1</source_block_id><sink_block_id>gr_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_xx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_1</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_noise_source_x_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_channel_model_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0_0</source_block_id><sink_block_id>gr_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fft_vxx_1</source_block_id><sink_block_id>gr_vector_to_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_interleave_0</source_block_id><sink_block_id>gr_fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0</source_block_id><sink_block_id>gr_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>pss_chan_est_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pss_chan_est_0</source_block_id><sink_block_id>gr_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>gr_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_1</source_block_id><sink_block_id>gr_vector_to_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_0_1</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_0_1_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_1_1</source_block_id><sink_block_id>gr_vector_to_stream_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_0_1_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>gr_vector_to_stream_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_0_1_0_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pss_chan_est_0</source_block_id><sink_block_id>gr_vector_to_stream_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_channel_model_0</source_block_id><sink_block_id>gr_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_1</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0_0_0</source_block_id><sink_block_id>gr_interleave_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0_0_0_0</source_block_id><sink_block_id>gr_interleave_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_interleave_1</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0</source_block_id><sink_block_id>gr_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_0_0</source_block_id><sink_block_id>gr_integrate_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_integrate_xx_0</source_block_id><sink_block_id>gr_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_repeat_0</source_block_id><sink_block_id>gr_conjugate_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_conjugate_cc_1</source_block_id><sink_block_id>gr_stream_to_vector_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_stream_to_vector_1_0</source_block_id><sink_block_id>virtual_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_interleave_1</source_block_id><sink_block_id>virtual_sink_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_2</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3_0</source_block_id><sink_block_id>gr_multiply_xx_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>gr_multiply_xx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_sub_xx_0</source_block_id><sink_block_id>gr_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_squared_0</source_block_id><sink_block_id>gr_vector_to_stream_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_0_2_0</source_block_id><sink_block_id>gr_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_float_0</source_block_id><sink_block_id>wxgui_scopesink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_float_0</source_block_id><sink_block_id>wxgui_scopesink2_0_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_0_2</source_block_id><sink_block_id>gr_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>wxgui_scopesink2_0_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>gr_vector_to_stream_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>gr_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fft_vxx_0</source_block_id><sink_block_id>gr_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_stream_to_vector_0</source_block_id><sink_block_id>gr_fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_deinterleave_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_deinterleave_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>gr_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0_1</source_block_id><sink_block_id>gr_interleave_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0_0_1</source_block_id><sink_block_id>gr_interleave_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>gr_vector_to_stream_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_0_2_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1</source_block_id><sink_block_id>gr_vector_to_stream_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_0_2_0_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3_1</source_block_id><sink_block_id>gr_vector_to_stream_0_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
