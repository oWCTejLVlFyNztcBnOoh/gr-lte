<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sss_equ2</value></param>
<param><key>title</key><value>SSS FD equalizer 2</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>gr-lte</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from pss_corr import *  </value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>from sss_corr import *   </value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>N_re</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_re</value></param>
<param><key>value</key><value>62</value></param>
</block>
<block>
<key>pss_chan_est3</key>
<param><key>id</key><value>pss_chan_est3_0</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>a_sss_vec_fd</value></param>
<param><key>label</key><value>sss</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>N_re</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>b_pss_vec_fd</value></param>
<param><key>label</key><value>pss</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>N_re</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>c_pss_1</value></param>
<param><key>label</key><value>ref</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>N_re</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>a_sss_est_fd</value></param>
<param><key>label</key><value>equ</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>N_re</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>b_sss_est_fd_0</value></param>
<param><key>label</key><value>est</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>N_re</value></param>
</block>
<connection><source_block_id>a_sss_vec_fd</source_block_id><sink_block_id>gr_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_1</source_block_id><sink_block_id>a_sss_est_fd</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_pss_vec_fd</source_block_id><sink_block_id>pss_chan_est3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pss_chan_est3_0</source_block_id><sink_block_id>gr_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>c_pss_1</source_block_id><sink_block_id>pss_chan_est3_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pss_chan_est3_0</source_block_id><sink_block_id>b_sss_est_fd_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
