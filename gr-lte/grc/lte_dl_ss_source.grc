<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lte_dl_ss_source</value></param>
<param><key>title</key><value>LTE DL synchronization signal</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>gr-lte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_id_1</value></param>
<param><key>value</key><value>134</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>from sss_corr import *   </value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from pss_corr import *  </value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_id_2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>16</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frames</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_re</value></param>
<param><key>value</key><value>2048/decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>30720e3/decim</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>.08</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>input_size</key><value>fft_size</value></param>
<param><key>output_size</key><value>fft_size+144/decim</value></param>
</block>
<block>
<key>gr_complex_to_arg</key>
<param><key>id</key><value>gr_complex_to_arg_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_complex_to_arg</key>
<param><key>id</key><value>gr_complex_to_arg_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>gr_interleave</key>
<param><key>id</key><value>gr_interleave_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>vlen</key><value>137</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_1_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size+9</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0_0_2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>gen_pss_td(N_id_2, N_re, 144).get_data()</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>fft_size+9</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0_0_2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>gen_sss_td(N_id_1, N_id_2, True, N_re).get_data()</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>fft_size+9</value></param>
</block>
<block>
<key>gr_interleave</key>
<param><key>id</key><value>gr_interleave_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0_0_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>tile(concatenate((gen_sss_td(N_id_1, N_id_2, True, N_re).get_data(), gen_pss_td(N_id_2, N_re, 144).get_data(),),1),1)</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>2048/decim</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_keep_m_in_n</key>
<param><key>id</key><value>gr_keep_m_in_n_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>m</key><value>fft_size</value></param>
<param><key>n</key><value>fft_size+144/decim</value></param>
<param><key>offset</key><value>symbol_start</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>gen_pss_fd(N_id_2, fft_size, False).get_data()</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>gen_sss_fd( N_id_1, N_id_2, fft_size).get_sss(True)</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>gr_fft_vxx</key>
<param><key>id</key><value>gr_fft_vxx_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value>window.blackmanharris(1024)</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>nthreads</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>gain</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>tile(concatenate((zeros((160+144*4+2048*5)/decim), gen_sss_td(N_id_1, N_id_2, True, N_re).get_data(), gen_pss_td(N_id_2, N_re, 144).get_data(), zeros((30720/2 + 30720*4)/decim), zeros((160+144*4+2048*5)/decim), gen_sss_td(N_id_1, N_id_2, False, N_re).get_data(), gen_pss_td(N_id_2, N_re, 144).get_data(), zeros((30720/2 + 30720*4)/decim)),1),frames)</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>wxgui_scopesink2_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>gr_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_1_0_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_interleave_0_0</source_block_id><sink_block_id>gr_vector_to_stream_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0_0_2_0_0</source_block_id><sink_block_id>gr_interleave_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0_0_2_0</source_block_id><sink_block_id>gr_interleave_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_arg_0</source_block_id><sink_block_id>wxgui_scopesink2_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_complex_to_arg_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>gr_complex_to_arg_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0_0</source_block_id><sink_block_id>gr_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_interleave_0</source_block_id><sink_block_id>gr_vector_to_stream_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_1_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>gr_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0_0</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0_0_2</source_block_id><sink_block_id>gr_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0_0_0</source_block_id><sink_block_id>gr_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0</source_block_id><sink_block_id>gr_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_fft_vxx_1</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>gr_keep_m_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fft_vxx_1</source_block_id><sink_block_id>gr_vector_to_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_interleave_0</source_block_id><sink_block_id>gr_fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
