<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from pss_corr import *  </value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>from sss_corr import *   </value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N_id_2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_re</value></param>
<param><key>value</key><value>62</value></param>
</block>
<block>
<key>pss_chan_est2</key>
<param><key>id</key><value>pss_chan_est2_0</value></param>
<param><key>N_id_2</key><value>N_id_2</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>N_re</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>sss_equ</value></param>
<param><key>title</key><value>SSS FD equalizer</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>gr-lte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>sss_vec_fd</value></param>
<param><key>label</key><value>sss</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>N_re</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pss_vec_fd</value></param>
<param><key>label</key><value>pss</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>N_re</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>sss_est_fd</value></param>
<param><key>label</key><value>est</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>N_re</value></param>
</block>
<connection><source_block_id>pss_chan_est2_0</source_block_id><sink_block_id>gr_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>sss_vec_fd</source_block_id><sink_block_id>gr_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pss_vec_fd</source_block_id><sink_block_id>pss_chan_est2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_1</source_block_id><sink_block_id>sss_est_fd</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
